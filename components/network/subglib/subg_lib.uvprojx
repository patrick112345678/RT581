# Keil uVision project subg_lib.uvprojx, settings and files
target thread_lib (6160000::V6.16::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: subg_lib (library)
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --strip=debug,symbols --elf --output=subg_lib.lib #L
  c flags: Optim=6 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CHIP_NAME='\"RT581\"',CONFIG_TARGET_BOARD='\"dongle\"',CONFIG_TARGET_CUSTOMER='\"das\"', OT_FREERTOS_ENABLE=1, CONFIG_CLI_CMD_ENABLE=1, CONFIG_UART_STDIO_BAUDRATE=UART_BAUDRATE_115200, RAFAEL_SDK_VER='\"1.0.3\"
  c misc: -fno-exceptions -fdata-sections -ffunction-sections
  c include: ..\rt569_rf\include;..\rt569mp\include;..\lmac15p4\Inc;..\ruci\include;..\subg_ctrl\Inc;..\..\utility\log;..\..\utility\cli\Inc;..\..\utility\utility\Inc;..\..\utility\MemoryMgmt\Inc;..\..\utility\EnhancedFlashDataset\Inc;..\..\platform\hosal\rt582_hosal\Inc;..\..\platform\soc\rt582\rt582_crypto\Inc;..\..\platform\soc\rt582\rt582_driver\Inc;..\..\platform\soc\rt582\rt582_freertos\Inc;..\..\platform\soc\rt582\rt582_freertos\config;..\..\..\examples\das_subg_evk\Include;..\..\platform\soc\rt582\rt582_freertos\portable\GCC\ARM_CM3
  asm define: USE_FREERTOS
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group rt569_rf
    ../rt569_rf/Src/: comm_subsystem_drv.c rf_common_init.c rf_mcu.c rf_mcu_ahb.c rf_mcu_spi.c rf_tx_comp.c
  group rt569mp
    ../rt569mp/Src/: rt569mp_fw.c rt569mp_init.c
  group lmac15p4
    ../lmac15p4/: lmac15p4.c
  group subg_ctrl
    ../subg_ctrl/: subg_ctrl.c
  group config
    ../../../examples/das_subg_evk/Include/: project_config.h
    ../../platform/soc/rt582/rt582_freertos/config/: FreeRTOSConfig.h
software components: CMSIS:CORE 5.5.0
