# Keil uVision project thread_lib.uvprojx, settings and files
target thread_lib (6160000::V6.16::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: thread_lib (library)
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --strip=debug,symbols --elf --output=thread_lib.lib #L
  c flags: Optim=6 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, OPENTHREAD_FTD, OPENTHREAD_PROJECT_CORE_CONFIG_FILE='\"openthread-core-RT58x-config.h\"', OPENTHREAD_CONFIG_FILE='\"openthread-core-RT58x-config.h\"', OPENTHREAD_CORE_CONFIG_PLATFORM_CHECK_FILE='\"openthread-core-rafael-config-check.h\"', MBEDTLS_CONFIG_FILE='\"mbedtls-config.h\"',PACKAGE_NAME='\"OPENTHREAD\"',PACKAGE_VERSION='\"2ce3d3bf0\"', CHIP_NAME='\"RT581\"',CONFIG_TARGET_BOARD='\"dongle\"',CONFIG_TARGET_CUSTOMER='\"das\"', OT_FREERTOS_ENABLE=1, CONFIG_CLI_CMD_ENABLE=1, CONFIG_UART_STDIO_PORT=2, CONFIG_UART_STDIO_BAUDRATE=UART_BAUDRATE_115200, CONFIG_UART1_PIN_4_5=3, NET_MGM_ENABLED=1, OPENTHREAD_CONFIG_RADIO_2P4GHZ_OQPSK_SUPPORT=0, OPENTHREAD_CONFIG_RADIO_915MHZ_OQPSK_SUPPORT=1, RAFAEL_SDK_VER='\"0.0.1\"
  c misc: -fno-exceptions -fdata-sections -ffunction-sections
  c include: ..\openthread_port\include;..\..\rt569_rf\include;..\..\rt569mp\include;..\..\lmac15p4\Inc;..\..\ruci\include;..\..\subg_ctrl\Inc;..\..\..\utility\log;..\..\..\utility\cli\Inc;..\..\..\utility\utility\Inc;..\..\..\utility\EnhancedFlashDataset\Inc;..\..\..\platform\hosal\rt582_hosal\Inc;..\..\..\platform\soc\rt582\rt582_crypto\Inc;..\..\..\platform\soc\rt582\rt582_driver\Inc;..\..\..\platform\soc\rt582\rt582_freertos\Inc;..\..\..\platform\soc\rt582\rt582_freertos\config;..\..\..\..\examples\das_subg_thread\das_subg_thread\Include;..\..\..\platform\soc\rt582\rt582_freertos\portable\GCC\ARM_CM3;..\subg_openthread\examples\platforms;..\subg_openthread\include;..\subg_openthread\src\cli;..\subg_openthread\src\core;..\subg_openthread\src\core\api;..\subg_openthread\src\core\backbone_router;..\subg_openthread\src\core\border_router;..\subg_openthread\src\core\coap;..\subg_openthread\src\core\common;..\subg_openthread\src\core\config;..\subg_openthread\src\core\crypto;..\subg_openthread\src\core\diags;..\subg_openthread\src\core\mac;..\subg_openthread\src\core\meshcop;..\subg_openthread\src\core\net;..\subg_openthread\src\core\radio;..\subg_openthread\src\core\thread;..\subg_openthread\src\core\utils;..\subg_openthread\third_party\mbedtls\repo\include;..\subg_openthread\third_party\mbedtls
  asm define: USE_FREERTOS
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group port
    ../openthread_port/: ot_alarm.c ot_crypto.c ot_diag.c ot_entropy.c ot_flash.c ot_freertos.c ot_logging.c ot_memory.c ot_misc.c ot_ota_handler.c ot_radio.c ot_settings.c ot_system.c ot_uart.c soft_source_match_table.c
  group rt569_rf
    ../../rt569_rf/Src/: comm_subsystem_drv.c rf_common_init.c rf_mcu.c rf_mcu_ahb.c rf_mcu_spi.c rf_tx_comp.c
  group rt569mp
    ../../rt569mp/Src/: rt569mp_fw.c rt569mp_init.c
  group lmac15p4
    ../../lmac15p4/: lmac15p4.c
  group subg_ctrl
    ../../subg_ctrl/: subg_ctrl.c
  group config
    ../openthread_port/include/: openthread-core-rafael-config.h openthread-core-rafael-config-check.h
    ../../../../examples/das_subg_thread/das_subg_thread/Include/: project_config.h
    ../../../platform/soc/rt582/rt582_freertos/config/: FreeRTOSConfig.h
software components: CMSIS:CORE 5.5.0
