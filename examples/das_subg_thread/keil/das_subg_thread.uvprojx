# Keil uVision project das_subg_thread.uvprojx, settings and files
target das_subg_thread (6160000::V6.16::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: das_subg_thread +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=Bin\@L.bin !L
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: NDEBUG, OPENTHREAD_FTD, OPENTHREAD_PROJECT_CORE_CONFIG_FILE='\"openthread-core-RT58x-config.h\"', OPENTHREAD_CONFIG_FILE='\"openthread-core-RT58x-config.h\"', OPENTHREAD_CORE_CONFIG_PLATFORM_CHECK_FILE='\"openthread-core-rafael-config-check.h\"', MBEDTLS_CONFIG_FILE='\"mbedtls-config.h\"',PACKAGE_NAME='\"OPENTHREAD\"',PACKAGE_VERSION='\"2ce3d3bf0\"', CHIP_NAME='\"RT581\"',CONFIG_TARGET_BOARD='\"dongle\"',CONFIG_TARGET_CUSTOMER='\"das\"', OT_FREERTOS_ENABLE=1, CONFIG_CLI_CMD_ENABLE=1, CONFIG_UART_STDIO_PORT=2, CONFIG_UART_STDIO_BAUDRATE=UART_BAUDRATE_115200, CONFIG_UART1_PIN_4_5=3, NET_MGM_ENABLED=1, OPENTHREAD_CONFIG_RADIO_2P4GHZ_OQPSK_SUPPORT=0, OPENTHREAD_CONFIG_RADIO_915MHZ_OQPSK_SUPPORT=1, RAFAEL_SDK_VER='\"0.0.1\"
  c misc: -fno-exceptions -fdata-sections -ffunction-sections
  c include: ..\..\..\components\network\thread\subg_openthread\examples\platforms;..\..\..\components\network\thread\subg_openthread\examples\platforms\utils;..\..\..\components\network\thread\subg_openthread\include;..\..\..\components\network\thread\subg_openthread\src;..\..\..\components\network\thread\subg_openthread\src\cli;..\..\..\components\network\thread\subg_openthread\src\core;..\..\..\components\network\thread\subg_openthread\src\core\api;..\..\..\components\network\thread\subg_openthread\src\core\backbone_router;..\..\..\components\network\thread\subg_openthread\src\core\border_router;..\..\..\components\network\thread\subg_openthread\src\core\coap;..\..\..\components\network\thread\subg_openthread\src\core\common;..\..\..\components\network\thread\subg_openthread\src\core\config;..\..\..\components\network\thread\subg_openthread\src\core\crypto;..\..\..\components\network\thread\subg_openthread\src\core\diags;..\..\..\components\network\thread\subg_openthread\src\core\mac;..\..\..\components\network\thread\subg_openthread\src\core\meshcop;..\..\..\components\network\thread\subg_openthread\src\core\net;..\..\..\components\network\thread\subg_openthread\src\core\radio;..\..\..\components\network\thread\subg_openthread\src\core\thread;..\..\..\components\network\thread\subg_openthread\src\core\utils;..\..\..\components\network\thread\subg_openthread\third_party\mbedtls\repo\include;..\..\..\components\network\thread\subg_openthread\third_party\mbedtls;..\..\..\components\network\thread\openthread_port\include;..\..\..\components\network\lmac15p4\Inc;..\..\..\components\network\rt569_rf\include;..\..\..\components\network\rt569mp\include;..\..\..\components\network\ruci\include;..\..\..\components\platform\hosal\rt582_hosal\Inc;..\..\..\components\platform\soc\rt582\rt582_crypto\Inc;..\..\..\components\platform\soc\rt582\rt582_driver\Inc;..\..\..\components\platform\soc\rt582\rt582_freertos\config;..\..\..\components\platform\soc\rt582\rt582_freertos\Inc;..\..\..\components\platform\soc\rt582\rt582_dongle\dongle\src;..\..\..\components\platform\soc\rt582\rt582_freertos\portable\GCC\ARM_CM3;..\..\..\components\utility\cli\Inc;..\..\..\components\utility\EnhancedFlashDataset\Inc;..\..\..\components\utility\log;..\..\..\components\utility\uart_stdio\Inc;..\..\..\components\utility\utility\Inc;..\das_subg_thread\Include
  asm define: USE_FREERTOS
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\das_subg_thread.sct
  group OT-API
    ../../../components/network/thread/subg_openthread/src/core/api/: backbone_router_api.cpp backbone_router_ftd_api.cpp border_agent_api.cpp border_router_api.cpp border_routing_api.cpp channel_manager_api.cpp channel_monitor_api.cpp child_supervision_api.cpp coap_api.cpp coap_secure_api.cpp commissioner_api.cpp crypto_api.cpp dataset_api.cpp dataset_ftd_api.cpp dataset_updater_api.cpp diags_api.cpp dns_api.cpp dns_server_api.cpp error_api.cpp heap_api.cpp history_tracker_api.cpp icmp6_api.cpp instance_api.cpp ip6_api.cpp jam_detection_api.cpp joiner_api.cpp link_api.cpp link_metrics_api.cpp link_raw_api.cpp logging_api.cpp mesh_diag_api.cpp message_api.cpp multi_radio_api.cpp nat64_api.cpp netdata_api.cpp netdata_publisher_api.cpp netdiag_api.cpp network_time_api.cpp ping_sender_api.cpp random_crypto_api.cpp random_noncrypto_api.cpp server_api.cpp sntp_api.cpp srp_client_api.cpp srp_client_buffers_api.cpp srp_server_api.cpp tasklet_api.cpp tcp_api.cpp tcp_ext_api.cpp thread_api.cpp thread_ftd_api.cpp trel_api.cpp udp_api.cpp
  group OT-Backbone_Router
    ../../../components/network/thread/subg_openthread/src/core/backbone_router/: backbone_tmf.cpp bbr_leader.cpp bbr_local.cpp bbr_manager.cpp multicast_listeners_table.cpp ndproxy_table.cpp
  group OT-Border_Router
    ../../../components/network/thread/subg_openthread/src/core/border_router/: infra_if.cpp routing_manager.cpp
  group OT-COAP
    ../../../components/network/thread/subg_openthread/src/core/coap/: coap.cpp coap_message.cpp coap_secure.cpp
  group OT-Common
    ../../../components/network/thread/subg_openthread/src/core/common/: appender.cpp binary_search.cpp crc16.cpp data.cpp error.cpp extension_example.cpp frame_builder.cpp frame_data.cpp heap.cpp heap_data.cpp heap_string.cpp instance.cpp log.cpp message.cpp notifier.cpp preference.cpp random.cpp settings.cpp string.cpp tasklet.cpp time_ticker.cpp timer.cpp tlvs.cpp trickle_timer.cpp uptime.cpp
  group OT-Crypto
    ../../../components/network/thread/subg_openthread/src/core/crypto/: aes_ccm.cpp aes_ecb.cpp crypto_platform.cpp hkdf_sha256.cpp hmac_sha256.cpp mbedtls.cpp sha256.cpp storage.cpp
  group OT-Diags
    ../../../components/network/thread/subg_openthread/src/core/diags/: factory_diags.cpp
  group OT-MAC
    ../../../components/network/thread/subg_openthread/src/core/mac/: channel_mask.cpp data_poll_handler.cpp data_poll_sender.cpp link_raw.cpp mac.cpp mac_filter.cpp mac_frame.cpp mac_links.cpp mac_types.cpp sub_mac.cpp sub_mac_callbacks.cpp
  group OT-Meshcop
    ../../../components/network/thread/subg_openthread/src/core/meshcop/: announce_begin_client.cpp border_agent.cpp commissioner.cpp dataset.cpp dataset_local.cpp dataset_manager.cpp dataset_manager_ftd.cpp dataset_updater.cpp dtls.cpp energy_scan_client.cpp extended_panid.cpp joiner.cpp joiner_router.cpp meshcop.cpp meshcop_leader.cpp meshcop_tlvs.cpp network_name.cpp panid_query_client.cpp timestamp.cpp
  group OT-Net
    ../../../components/network/thread/subg_openthread/src/core/net/: checksum.cpp dhcp6_client.cpp dhcp6_server.cpp dns_client.cpp dns_dso.cpp dns_platform.cpp dns_types.cpp dnssd_server.cpp icmp6.cpp ip4_types.cpp ip6.cpp ip6_address.cpp ip6_filter.cpp ip6_headers.cpp ip6_mpl.cpp nat64_translator.cpp nd_agent.cpp nd6.cpp netif.cpp sntp_client.cpp socket.cpp srp_client.cpp srp_server.cpp tcp6.cpp tcp6_ext.cpp udp6.cpp
  group OT-Radio
    ../../../components/network/thread/subg_openthread/src/core/radio/: radio.cpp radio_callbacks.cpp radio_platform.cpp trel_interface.cpp trel_link.cpp trel_packet.cpp
  group OT-Thread
    ../../../components/network/thread/subg_openthread/src/core/thread/: address_resolver.cpp announce_begin_server.cpp announce_sender.cpp anycast_locator.cpp child_supervision.cpp child_table.cpp csl_tx_scheduler.cpp discover_scanner.cpp dua_manager.cpp energy_scan_server.cpp indirect_sender.cpp key_manager.cpp link_metrics.cpp link_metrics_types.cpp link_quality.cpp lowpan.cpp mesh_forwarder.cpp mesh_forwarder_ftd.cpp mesh_forwarder_mtd.cpp mle.cpp mle_router.cpp mle_tlvs.cpp mle_types.cpp mlr_manager.cpp neighbor_table.cpp network_data.cpp network_data_leader.cpp network_data_leader_ftd.cpp network_data_local.cpp network_data_notifier.cpp network_data_publisher.cpp network_data_service.cpp network_data_tlvs.cpp network_data_types.cpp network_diagnostic.cpp panid_query_server.cpp radio_selector.cpp router_table.cpp src_match_controller.cpp thread_netif.cpp time_sync_service.cpp tmf.cpp topology.cpp uri_paths.cpp
  group OT-Utils
    ../../../components/network/thread/subg_openthread/src/core/utils/: channel_manager.cpp channel_monitor.cpp flash.cpp heap.cpp history_tracker.cpp jam_detector.cpp mesh_diag.cpp otns.cpp parse_cmdline.cpp ping_sender.cpp power_calibration.cpp slaac_address.cpp srp_client_buffers.cpp
  group OT-CLI
    ../../../components/network/thread/subg_openthread/src/cli/: cli.cpp cli_br.cpp cli_coap.cpp cli_coap_secure.cpp cli_commissioner.cpp cli_dataset.cpp cli_history.cpp cli_joiner.cpp cli_network_data.cpp cli_output.cpp cli_srp_client.cpp cli_srp_server.cpp cli_tcp.cpp cli_udp.cpp
    ../../../components/network/thread/subg_openthread/examples/apps/cli/: cli_uart.cpp
  group mbedTLS
    ../../../components/network/thread/subg_openthread/third_party/mbedtls/repo/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c constant_time.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c memory_buffer_alloc.c mps_reader.c mps_trace.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_cipher.c psa_crypto_client.c psa_crypto_driver_wrappers.c psa_crypto_ecp.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_rsa.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c ssl_tls13_keys.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group utils
    ../../../components/network/thread/subg_openthread/examples/platforms/utils/: debug_uart.c logging_rtt.c settings_ram.c soft_source_match_table.c link_metrics.cpp mac_frame.cpp otns_utils.cpp
  group Platform
    ../../../components/network/thread/thread_lib/: thread_lib.lib
  group SDK-Hosal
    ../../../components/platform/hosal/rt582_hosal/Src/: hosal_rf.c hosal_uart.c
  group SDK-Driver
    ../../../components/platform/soc/rt582/rt582_driver/Src/: comparator.c dma.c flashctl.c gpio.c i2c_master.c i2s.c lpm.c mp_sector.c pwm.c qspi.c rtc.c sadc.c swi.c swt.c sysctrl.c sysfun.c system_cm3_mcu.c timer.c wdt.c uart_retarget.c
  group SDK-Crypto
    ../../../components/platform/soc/rt582/rt582_crypto/: rt_aes.c rt_crypto.c rt_crypto_util.c rt_ecjpake.c rt_hmac_drbg.c rt_sha256.c
  group SDK-Dongle
    ../../../components/platform/soc/rt582/rt582_dongle/dongle/src/: debug.c memmove.c sscanf.c strntoumax.c vsscanf.c system_cm3_mcu.c
    ../../../components/platform/soc/rt582/rt582_dongle/dongle/src/boot/ARM/: startup_cm3_mcu.s
    ../../../components/platform/soc/rt582/rt582_dongle/: rt_main.c
  group SDK-Cli
    ../../../components/utility/cli/: cli.c shell.c
  group SDK-Log
    ../../../components/utility/log/: log.c
  group SDK-UartStdio
    ../../../components/utility/uart_stdio/: uart_stdio.c
  group SDK-Utility
    ../../../components/utility/utility/: util_list.c util_log.c util_string.c
  group SDK-FreeRtos
    ../../../components/platform/soc/rt582/rt582_freertos/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../components/platform/soc/rt582/rt582_freertos/portable/GCC/ARM_CM3/: port.c
    ../../../components/platform/soc/rt582/rt582_freertos/portable/MemMang/: heap_5.c
  group Application
    ../das_subg_thread/: main.c app_task.c app_uart.c app_udp.c das_dlms_cmd.c das_hex_cmd.c network_management.c
  group Config
    ../das_subg_thread/Include/: project_config.h
    ../../../components/network/thread/openthread_port/include/: openthread-core-RT58x-config.h
    ../../../components/platform/soc/rt582/rt582_freertos/config/: FreeRTOSConfig.h
  group EnhancedFlashDataset
    ../../../components/utility/EnhancedFlashDataset/Src/: efd_iap.c efd_kv.c efd_log.c efd_port.c efd_utils.c EnhancedFlashDataset.c
software components: CMSIS:CORE 5.5.0
