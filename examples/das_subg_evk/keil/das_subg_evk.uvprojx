# Keil uVision project das_subg_evk.uvprojx, settings and files
target das_subg_thread (6160000::V6.16::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: das_subg_evk +hex
  BeforeMake: python C:\Users\testo\Desktop\rafel_das_watchdog\rafael-iot-sdk-das-Release_v1.0.0\rafael-iot-sdk-das-Release_v1.0.0\update_version.py
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=Bin\@L.bin !L
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: NDEBUG, CHIP_NAME='\"RT581\"',CONFIG_TARGET_BOARD='\"dongle\"',CONFIG_TARGET_CUSTOMER='\"das\"', OT_FREERTOS_ENABLE=1, CONFIG_CLI_CMD_ENABLE=1, CONFIG_UART_STDIO_BAUDRATE=UART_BAUDRATE_115200, RAFAEL_SDK_VER='\"1.0.3\"
  c misc: -fno-exceptions -fdata-sections -ffunction-sections
  c include: ..\..\..\components\network\lmac15p4\Inc;..\..\..\components\network\rt569_rf\include;..\..\..\components\network\rt569mp\include;..\..\..\components\network\subg_ctrl\Inc;..\..\..\components\network\ruci\include;..\..\..\components\platform\hosal\rt582_hosal\Inc;..\..\..\components\platform\soc\rt582\rt582_crypto\Inc;..\..\..\components\platform\soc\rt582\rt582_driver\Inc;..\..\..\components\platform\soc\rt582\rt582_freertos\config;..\..\..\components\platform\soc\rt582\rt582_freertos\Inc;..\..\..\components\platform\soc\rt582\rt582_dongle\dongle\src;..\..\..\components\platform\soc\rt582\rt582_freertos\portable\GCC\ARM_CM3;..\..\..\components\utility\cli\Inc;..\..\..\components\utility\EnhancedFlashDataset\Inc;..\..\..\components\utility\log;..\..\..\components\utility\uart_stdio\Inc;..\..\..\components\utility\utility\Inc;..\..\..\components\utility\MemoryMgmt\Inc;..\Include
  asm define: USE_FREERTOS
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\das_subg_evk.sct
  group SDK-Hosal
    ../../../components/platform/hosal/rt582_hosal/Src/: hosal_rf.c hosal_uart.c
  group SDK-Driver
    ../../../components/platform/soc/rt582/rt582_driver/Src/: comparator.c dma.c flashctl.c flashds.c flash_protect.c gpio.c lpm.c mp_sector.c sysctrl.c sysfun.c timer.c wdt.c
  group SDK-Crypto
    ../../../components/platform/soc/rt582/rt582_crypto/: rt_aes.c rt_crypto.c rt_crypto_util.c rt_ecjpake.c rt_hmac_drbg.c rt_sha256.c
  group SDK-Dongle
    ../../../components/platform/soc/rt582/rt582_dongle/dongle/src/: debug.c memmove.c sscanf.c strntoumax.c vsscanf.c system_cm3_mcu.c
    ../../../components/platform/soc/rt582/rt582_dongle/dongle/src/boot/ARM/: startup_cm3_mcu.s
    ../../../components/platform/soc/rt582/rt582_dongle/: rt_main.c
  group SDK-Cli
    ../../../components/utility/cli/: cli.c shell.c
  group SDK-UartStdio
    ../../../components/utility/uart_stdio/: uart_stdio.c
  group SDK-Utility
    ../../../components/utility/utility/: util_list.c util_string.c
  group SDK-FreeRtos
    ../../../components/platform/soc/rt582/rt582_freertos/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../components/platform/soc/rt582/rt582_freertos/portable/GCC/ARM_CM3/: port.c
    ../../../components/platform/soc/rt582/rt582_freertos/portable/MemMang/: heap_5.c
  group SDK-MemoryMgmt
    ../../../components/utility/MemoryMgmt/: mem_mgmt.c
  group Subg_lib
    ../../../components/network/subglib/: subg_lib.lib
  group Application
    ../: app_task.c app_uart.c main.c mac_frame_gen.c
  group EnhancedFlashDataset
    ../../../components/utility/EnhancedFlashDataset/Src/: efd_iap.c efd_kv.c efd_log.c efd_port.c efd_utils.c EnhancedFlashDataset.c
software components: CMSIS:CORE 5.5.0
